# Keil uVision project DX_LoRa_Test.uvprojx, settings and files
target SPI_TESET (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 902M +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,W25Q64=1
  c include: ..\Core;..\Driver;..\Main;..\SDK\CMSIS\Include;..\SDK\CMSIS\Device\ST\STM32F1xx\Include;..\SDK\STM32F1xx_HAL_Driver\Inc;..\SDK\STM32F1xx_HAL_Driver\Src;..\sx126x_driver\src;..\sx126x_driver;..\quequ;..\LR_driver\src;..\LR_driver;..\SDK\CMSIS\Include;C:\Users\Administrator\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Main/: main.c
  group Core
    ../Core/: stm32f1xx_it.c stm32f1xx_clk.c stm32f1xx_hal_conf.h system_stm32f1xx.c startup_stm32f103xe.s
  group Driver
    ../Driver/: driver_usart.c driver_spi.c driver_key.c driver_timer.c
  group SDK
    ../SDK/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group LR
    ../LR_driver/src/: lr_fhss_mac.c sx126x.c sx126x_driver_version.c sx126x_hal.c sx126x_lr_fhss.c
    ../LR_driver/: UserConfig.c
  group queue
    ../quequ/: myqueue.c
